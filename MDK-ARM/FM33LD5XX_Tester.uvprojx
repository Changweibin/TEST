# Keil uVision project FM33LD5XX_Tester.uvprojx, settings and files
target Example (6220000::V6.22::ARMCLANG)
  device: FM33LD54X FMSH
  pack: FMSH.FM33LD5XX_DFP.1.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x00000000,0x40000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 v6Lang=5 v6LangP=3 wLevel=4
  c define: FM33LD5XX,USE_FULL_ASSERT
  c include: ..\Drivers\CMSIS\Device\FM\FM33xx\Include;..\Inc;..\MF-config\Inc;..\Drivers\FM33LD5xx_FL_Driver\Inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\FM33LD54XX.sct
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33ld5xx.S
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
    ../Src/: pll.c
  group Application/User
    ../Src/: main.c user_process.c FOC.c MotorCtr.c Filter.c HFI.c PI_Cale.c Coordinate_Trans.c SVPWM.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33ld5xx.c
  group Drivers/FM33LD5xx_FL_Driver
    ../Drivers/FM33LD5xx_FL_Driver/Src/: fm33ld5xx_fl.c fm33ld5xx_fl_cmu.c fm33ld5xx_fl_flash.c fm33ld5xx_fl_gpio.c fm33ld5xx_fl_exti.c fm33ld5xx_fl_atim.c fm33ld5xx_fl_bstim16.c fm33ld5xx_fl_canfd.c fm33ld5xx_fl_clm.c fm33ld5xx_fl_comp.c fm33ld5xx_fl_cordic.c fm33ld5xx_fl_crc.c fm33ld5xx_fl_dac.c fm33ld5xx_fl_dma.c fm33ld5xx_fl_gptim.c fm33ld5xx_fl_i2c.c fm33ld5xx_fl_iwdt.c fm33ld5xx_fl_lptim16.c fm33ld5xx_fl_pgl.c fm33ld5xx_fl_pmu.c fm33ld5xx_fl_qspi.c fm33ld5xx_fl_spi.c fm33ld5xx_fl_svd.c fm33ld5xx_fl_tau.c fm33ld5xx_fl_uart.c fm33ld5xx_fl_wwdt.c fm33ld5xx_fl_adc.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2
